# Keil uVision project WEH-210.uvprojx, settings and files
target WEH-210 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: WEH-210 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F407xx,USE_HAL_DRIVER,STM32_THREAD_SAFE_STRATEGY=4
  c include: ../Appl/menuManager;../Appl/programManager;../Appl/ioManager;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/Fsm;../Middlewares/Third_Party/Lcd;../Middlewares/Third_Party/MemIf;../Middlewares/Third_Party/eModbus/modbus/include;../Middlewares/Third_Party/eModbus/modbus/rtu;../Middlewares/Third_Party/eModbus/port;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/AT24C32;../Drivers/BSP/ST7565R;../Utilities/Fonts
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/menuManager
    ../Appl/menuManager/: menuManager.c _A000000000_menu_PowerOn.c _B000000000_menu_Init.c _0000000000_menu_Home.c _1000000000_menu_MainSetting.c _1100000000_menu_SetToDefault.c _1110000000_menu_SetDefaultParam.c _1120000000_menu_SetDefaultProg.c _1200000000_menu_MachineSetup.c _1210000000_menu_MachineFuncSetup.c _1211000000_menu_DrainWhileDoorOpen.c _1212000000_menu_HeatUseTimeout.c _1213000000_menu_FillUseTimeout.c _1214000000_menu_ManOperateWhenAuto.c _1215000000_menu_TempUnit.c _1216000000_menu_DrainValveStatus.c _1220000000_menu_InputStatusSetup.c _1221000000_menu_DoorClosed.c _1222000000_menu_ExtractShock.c _1223000000_menu_EmergencyStop.c _1224000000_menu_InverterError.c _1230000000_menu_FillLevelSetup.c _1231000000_menu_AutoRefillWhenLow.c _1232000000_menu_ZeroLevel.c _1233000000_menu_LowLevel.c _1234000000_menu_MidLevel.c _1235000000_menu_HighLevel.c _1236000000_menu_OverbrimLevel.c _1237000000_menu_LevelDiffRefill.c _1238000000_menu_MaxTimeFill.c _1240000000_menu_HeatTempSetup.c _1241000000_menu_AutoReheatWhenLow.c _1242000000_menu_MinWaterTemp.c _1243000000_menu_MaxWaterTemp.c _1244000000_menu_TempThreshold.c _1245000000_menu_TempDiffReheat.c _1246000000_menu_MaxTimeHeat.c _1250000000_menu_SoapSetup.c _1251000000_menu_StopFillWhenSoap.c _1252000000_menu_TimeSoap1.c _1253000000_menu_TimeSoap2.c _1254000000_menu_TimeSoap3.c _1260000000_menu_WashSetup.c _1261000000_menu_MinPauseFwdRev.c _1262000000_menu_StdWashRunTime.c _1263000000_menu_StdWashStopTime.c _1264000000_menu_DelWashRunTime.c _1265000000_menu_DelWashStopTime.c _1266000000_menu_HvyWashRunTime.c _1267000000_menu_HvyWashStopTime.c _1268000000_menu_StdWashSpeed.c _1269000000_menu_DelWashSpeed.c _126A000000_menu_HvyWashSpeed.c _126B000000_menu_MaxWashSpeed.c _1270000000_menu_ExtractSetup.c _1271000000_menu_BalanceLevel.c _1272000000_menu_BalanceDrainLevel.c _1273000000_menu_BalanceWithWaterTime.c _1274000000_menu_BalanceDrainWaterTime.c _1275000000_menu_BalanceDelayTime.c _1276000000_menu_FwdRunTime.c _1277000000_menu_MidExtractTime.c _1278000000_menu_MidExtractDelayTime.c _1279000000_menu_HighExtractTime1.c _127A000000_menu_HighExtractTime2.c _127B000000_menu_HighExtractTime3.c _127C000000_menu_HighExtractDelayTime.c _127D000000_menu_MaxExtractTime.c _127E000000_menu_ReextractTime.c _127F000000_menu_ReextractWashTime.c _127G000000_menu_BalanceSpeed.c _127H000000_menu_FwdRunSpeed.c _127I000000_menu_MidExtractSpeed.c _127J000000_menu_HighExtractSpeed1.c _127K000000_menu_HighExtractSpeed2.c _127L000000_menu_HighExtractSpeed3.c _127M000000_menu_MaxMidExtractSpeed.c _127N000000_menu_MaxHighExtractSpeed.c _1280000000_menu_DoorLockSetup.c _1281000000_menu_UseLockStopButton.c _1282000000_menu_DoorLockValveStatus.c _1283000000_menu_UnlockDoorTemp.c _1284000000_menu_UnlockDoorLevel.c _1300000000_menu_ProgramSetup.c _1310000000_menu_ProgramStepSetup.c _1311000000_menu_ProgramMainSetup.c _1311100000_menu_StepIsActive.c _1311200000_menu_StepWaterMode.c _1311300000_menu_StepSoapMode.c _1311400000_menu_StepWashMode.c _1311410000_menu_StepWashModeCustom.c _1311411000_menu_StepWashRunTime.c _1311412000_menu_StepWashStopTime.c _1311413000_menu_StepWashSpeed.c _1311500000_menu_StepWashNum.c _1311600000_menu_StepTempMode.c _1311610000_menu_StepTempModeCustom.c _1311700000_menu_StepLevelMode.c _1311710000_menu_StepLevelModeCustom.c _1311800000_menu_StepExtractParam.c _1311810000_menu_StepBalanceTime.c _1311820000_menu_StepMidExtractTime.c _1311830000_menu_StepHighExtractTime1.c _1311840000_menu_StepHighExtractTime2.c _1311850000_menu_StepHighExtractTime3.c menuManager_Common.c
  group Application/programManager
    ../Appl/programManager/: programManager.c _A000000000_program_PowerOn.c _B000000000_program_Init.c _0000000000_program_Idle.c _1000000000_program_AutoInit.c _2000000000_program_ManualInit.c programManager_Mem.c programManager_Control.c programManager_Common.c
  group Application/ioManager
    ../Appl/ioManager/: ioManager.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s armlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c crc.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Middlewares/Fsm
    ../Middlewares/Third_Party/Fsm/: fsm.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Lcd
    ../Middlewares/Third_Party/Lcd/: lcd.c
  group Middlewares/MemIf
    ../Middlewares/Third_Party/MemIf/: memIf.c
  group Middlewares/eModbus
    ../Middlewares/Third_Party/eModbus/modbus/src/: eMB.c eMB_FuncCoils.c eMB_FuncDiag.c eMB_FuncDisInputs.c eMB_FuncHolding.c eMB_FuncInput.c eMB_FuncOther.c eMB_Utils.c
    ../Middlewares/Third_Party/eModbus/modbus/rtu/: eMB_RTU.c eMB_CRC.c
    ../Middlewares/Third_Party/eModbus/port/: eMB_PortEvent.c eMB_PortSerial.c eMB_PortTimer.c eMB_PortUtils.c eMB_Cfg.h eMB_LCfg.c
  group Drivers/MCAL
    ../Drivers/BSP/AT24C32/: at24c32.c
    ../Drivers/BSP/ST7565R/: st7565r.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Utilities/Fonts
    ../Utilities/Fonts/: font_6x8.c font_8x16.c
software components: CMSIS:CORE 5.6.0
